<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OB1203RL78L13_cpp.ewp</path>
    </project>
    <batchBuild />
</workspace>
