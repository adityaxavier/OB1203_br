# IAR project OB1203RL78L13.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F10WMG RL78 - R5F10WMG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 1024
  General.GenNearHeapSize: 512
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 1
  ICCRL78.CCDefines: USE_BRUTE_DELAY; DEBUG; MEASURE_PERFORMANCE
  ICCRL78.CCIncludePath2: cg_src; OB1203; SPO2; LCD
  OBJCOPY.OOCOutputFile: OB1203RL78L13.srec
  ILINK.IlinkOutputFile: OB1203RL78L13_cpp.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: OB1203; r_iic_drv_rl78
  OBJCOPY.OOCOutputFile: OB1203RL78L13_cpp.srec
configuration RawLog (RL78, debug)
  as the first configuration, except:
  General.GenNearHeapSize: 256
  ICCRL78.CCDefines: USE_BRUTE_DELAY; DEBUG; MEASURE_PERFORMANCE; PRINT_RAW_STREAM
configuration DebugUnity (RL78, debug)
  as the first configuration, except:
  General.GenNearHeapSize: 256
  ICCRL78.CCDefines: DEBUG; USE_BRUTE_DELAY; MEASURE_PERFORMANCE; UNITY_TESTING; UNITY_USE_LIMITS_H; UNITY_EXCLUDE_STDINT_H
  ICCRL78.CCIncludePath2: cg_src; OB1203; SPO2; LCD; unity
  group (top)
    ./: main.cpp
  group cg_src
    cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_dmac.c r_cg_dmac.h r_cg_dmac_user.c r_cg_iica.c r_cg_iica.h r_cg_iica_user.c r_cg_intp.c r_cg_intp.h r_cg_intp_user.c r_cg_it.c r_cg_it.h r_cg_it_user.c r_cg_lcd.c r_cg_lcd.h r_cg_lcd_user.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_rtc.c r_cg_rtc.h r_cg_rtc_user.c r_cg_sau.c r_cg_sau.h r_cg_sau_user.c r_cg_systeminit.c r_cg_userdefine.h
  group LCD
    LCD/: lcd_panel.c lcd_panel.h ppg_lcd.c ppg_lcd.h
  group OB1203
    OB1203/: OB1203.cpp OB1203.h
  group SERIAL
    SERIAL/: write.c
  group SPO2
    SPO2/: SPO2.cpp SPO2.h
  group TEST
    test/: AllTests.c testOB1203.cpp testOB1203_Fixture_Runner.cpp testSPO2.cpp testSPO2_Fixture_Runner.cpp
  group UNITY
    unity/: unity.c unity.h unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h unity_internals.h
