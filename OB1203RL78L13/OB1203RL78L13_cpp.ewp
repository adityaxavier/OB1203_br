# IAR project OB1203RL78L13_cpp.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F10WMG RL78 - R5F10WMG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 1
  ICCRL78.CCIncludePath2: r_iic_drv_rl78; OB1203
  OBJCOPY.OOCOutputFile: OB1203RL78L13_cpp.srec
  ILINK.IlinkOutputFile: OB1203RL78L13_cpp.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: OB1203; r_iic_drv_rl78
configuration Debug-CodeGen (RL78, debug)
  as the first configuration, except:
  General.GenStackSize: 512
  ICCRL78.CCDefines: USE_CG
  ICCRL78.CCIncludePath2: cg_src; OB1203
  group (top)
    ./: main.cpp
  group cg_src
    cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_iica.c r_cg_iica.h r_cg_iica_user.c r_cg_intp.c r_cg_intp.h r_cg_intp_user.c r_cg_macrodriver.h r_cg_main.c r_cg_systeminit.c r_cg_userdefine.h
  group OB1203
    OB1203/: OB1203.cpp OB1203.h
  group r_iic_drv
    r_iic_drv_rl78/: r_iic_drv_api.c r_iic_drv_api.h r_iic_drv_int.c r_iic_drv_int.h r_iic_drv_os.c r_iic_drv_os.h r_iic_drv_sfr.h r_iic_drv_sfr_rl78l13.c r_iic_drv_sub.c r_iic_drv_sub.h
